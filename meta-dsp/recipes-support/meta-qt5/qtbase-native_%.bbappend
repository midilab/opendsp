PACKAGECONFIG:append = " gui imageformats"

