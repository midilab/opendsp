require ${BPN}.inc

inherit native


