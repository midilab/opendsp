# class for audio plugin common settings

# plugin package names
PN_DSSI = "${PN}-dssi"
PN_LADSPA = "${PN}-ladspa"
PN_LV2 = "${PN}-lv2"
PN_VST = "${PN}-vst"
PN_VST3 = "${PN}-vst3"

