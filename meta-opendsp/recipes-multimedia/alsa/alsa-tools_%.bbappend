PACKAGECONFIG += " hdspmixer hdsploader"
