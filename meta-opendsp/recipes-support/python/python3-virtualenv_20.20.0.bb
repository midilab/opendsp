SUMMARY = "Recipe to embedded the Python PiP Package virtualenv"
HOMEPAGE ="https://pypi.org/project/virtualenv"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0ce089158cf60a8ab6abb452b6405538"

PYPI_PACKAGE = "virtualenv"
SRC_URI[sha256sum] = "a8a4b8ca1e28f864b7514a253f98c1d62b64e31e77325ba279248c65fb4fcef4"

inherit pypi setuptools3